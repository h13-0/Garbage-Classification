# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\Project;..\Stm32F10x_FWLIB\inc;..\Driver\MPU6050;..\Driver\MPU6050\eMPL;..\Driver\OLED12864_I2C;..\Hardware;..\Software\ANO_tc;..\Software\BLUEROCKER;..\Software\PID;..\Software\sys;..\Software\usart;..\Software\USMART;..\Driver\H-Bridge;..\Driver\Holder;..\Driver\MLX90614;..\Driver\ST7789V_240x240_Intel8080;..\Driver\Ultrasonic_Ranging;..\Driver\VL53L0X\core\inc;..\Driver\VL53L0X\platform\inc;..\Hardware\Intel8080;..\Software\SystemClock;..\Hardware\SoftI2C;..\Software\Bit_operation
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: core_cm3.c startup_stm32f101_103_md_Max128k.s
  group Driver
    ../Driver/MPU6050/: mpu6050.c mpuiic.c
    ../Driver/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Driver/OLED12864_I2C/: OLED_I2C.c
    ../Driver/H-Bridge/: H-Bridge.c
    ../Driver/Holder/: holder.c
    ../Driver/MLX90614/: mlx90614.c
    ../Driver/Ultrasonic_Ranging/: Ultrasonic_Ranging.c
    ../Driver/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_easy_api.c vl53l0x_it.c
    ../Driver/ST7789V_240x240_Intel8080/: ST7789V_240x240_Intel8080.c
    ../Driver/VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
  group Hardware
    ../Hardware/Intel8080/: Intel8080.c
    ../Hardware/SoftI2C/: SoftI2C.c
  group Project
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Software
    ../Software/ANO_tc/: ANO_tc.c
    ../Software/BLUEROCKER/: BlueRocker.c
    ../Software/PID/: PID.c
    ../Software/sys/: sys.c
    ../Software/usart/: usart.c
    ../Software/SystemClock/: SystemClock.c
  group FWLIB
    ../Stm32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
